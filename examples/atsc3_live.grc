options:
  parameters:
    id: atsc3_live
    title: 'rxtune on a real radio: ATSC 3.0'
    author: gr-rxtune
    generate_options: qt_gui
    output_language: python
    description: The controller tunes an SDRplay's gain elements by message while an external ATSC 3.0 receiver judges each capture.
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 6.912e6
  states: {}
- name: freq
  id: parameter
  parameters:
    label: Channel centre (Hz)
    type: eng_float
    value: 600e6
    short_id: f
  states: {}
- name: antenna
  id: parameter
  parameters:
    label: Antenna port
    type: str
    value: '"Antenna A"'
    short_id: a
  states: {}
- name: receiver_dir
  id: parameter
  parameters:
    label: ATSC 3.0 receiver tree
    type: str
    value: '"."'
    short_id: r
  states: {}
- name: py
  id: parameter
  parameters:
    label: Python for the receiver
    type: str
    value: '"python"'
    short_id: p
  states: {}
- name: judges
  id: variable
  parameters:
    value: rxtune_recipes.atsc3(receiver_dir, py)
    comment: '(score, prove): the receiver''s own tools'
  states: {}
- name: import_recipes
  id: import
  parameters:
    imports: from rxtune import recipes as rxtune_recipes
  states: {}
- name: note_radio
  id: note
  parameters:
    note: 1. THE RADIO
  states: {}
- name: sdr
  id: soapy_sdrplay_source
  parameters:
    type: fc32
    samp_rate: samp_rate
    antenna: antenna
    center_freq: freq
    lna_state: '4'
    comment: gains arrive on 'cmd', per element
  states: {}
- name: spectrum
  id: qtgui_freq_sink_x
  parameters:
    type: complex
    name: '"ATSC 3.0 carrier (baseband)"'
    fftsize: '2048'
    fc: '0'
    bw: samp_rate
    average: '0.05'
    gui_hint: 0,0,1,1
  states: {}
- name: waterfall
  id: qtgui_waterfall_sink_x
  parameters:
    type: complex
    name: '"waterfall"'
    fftsize: '2048'
    fc: '0'
    bw: samp_rate
    gui_hint: 0,1,1,1
  states: {}
- name: note_loop
  id: note
  parameters:
    note: 2. JUDGE + LOOP
  states: {}
- name: capture
  id: rxtune_capture_dial
  parameters:
    samp_rate: samp_rate
    secs: '5.0'
    settle_s: '1.0'
    path: rxtune_capture.cf32
    score: judges[0]
    prove: judges[1]
    comment: record 5 s per cell; SNR off the dummy cells + a real decode
  states: {}
- name: ctl
  id: rxtune_controller
  parameters:
    axes: '[{"name": "gain:RFGR", "lo": 0, "hi": 12, "step": 1, "sense": "reduction"}, {"name": "gain:IFGR", "lo": 20, "hi": 59, "step": 1, "sense": "reduction"}]'
    dialect: soapy
    dial_name: SNR
    settle_s: '1.0'
    window_s: '240'
    min_samples: '1'
    coarse_points: '3'
    max_cells: '22'
    comment: 'Window is a ceiling: cells close when the judgement arrives'
  states: {}
- name: dash
  id: rxtune_dashboard
  parameters:
    label: 'rxtune: ATSC 3.0'
    units: dB
    dial_max: '30'
    gui_hint: 1,0,1,2
  states: {}
- name: debug
  id: blocks_message_debug
  parameters: {}
  states: {}

connections:
- [sdr, '0', spectrum, '0']
- [sdr, '0', waterfall, '0']
- [sdr, '0', capture, '0']
- [ctl, status, capture, status]
- [capture, dial, ctl, dial]
- [capture, liveness, ctl, liveness]
- [ctl, cmd, sdr, cmd]
- [capture, dial, dash, dial]
- [ctl, status, dash, status]
- [ctl, verdict, dash, verdict]
- [ctl, verdict, debug, print]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
